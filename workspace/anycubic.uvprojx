# Keil uVision project anycubic.uvprojx, settings and files
target firmware_Release (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HC32F460PETB HDSC
  pack: HDSC.HC32F460.1.0.7
  cpu: IRAM(0x1FFF8000,0x8000) IRAM2(0x20000000,0x10000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: firmware +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=4 v6LangP=3 wLevel=1
  c define: HC32F46x,USE_DEVICE_DRIVER_LIB,__TARGET_FPU_VFP,__FPU_PRESENT=1,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,__MPU_PRESENT=1,STM32_HIGH_DENSITY,ARDUINO_ARCH_STM32F1,ARDUINO_ARCH_STM32
  c misc: --gnu --diag_suppress=186,66 --cpp11 --multifile
  c include: ..\source\compoment\adc;..\source\compoment\i2c;..\source\compoment\sdio;..\source\compoment\sdio\sd_card\inc;..\source\compoment\spi;..\source\compoment\uart;..\source\compoment\Utility;..\source\drivers\board;..\source\drivers\library;..\source\drivers\library\inc;..\source\framework\cores;..\source\framework\usb;..\source\framework\variants;..\source\main;..\source\main\hdsc32core;..\source\marlin\marlin;..\source\marlin\marlin\src;..\source\marlin\marlin\src\pins;..\source\marlin\marlin\src\core;..\source\marlin\marlin\src\feature;..\source\marlin\marlin\src\feature\bedlevel;..\source\marlin\marlin\src\feature\bedlevel\abl;..\source\marlin\marlin\src\feature\bedlevel\mbl;..\source\marlin\marlin\src\feature\bedlevel\ubl;..\source\marlin\marlin\src\feature\digipot;..\source\marlin\marlin\src\feature\leds;..\source\marlin\marlin\src\feature\mmu;..\source\marlin\marlin\src\feature\password;..\source\marlin\marlin\src\gcode;..\source\marlin\marlin\src\HAL;..\source\marlin\marlin\src\HAL\shared;..\source\marlin\marlin\src\HAL\shared\backtrace;..\source\marlin\marlin\src\HAL\STM32;..\source\marlin\marlin\src\HAL\STM32\tft;..\source\marlin\marlin\src\HAL\STM32\inc;..\source\marlin\marlin\src\inc;..\source\marlin\marlin\src\lcd;..\source\marlin\marlin\src\lcd\dogm;..\source\marlin\marlin\src\lcd\dogm\fontdata;..\source\marlin\marlin\src\lcd\dwin;..\source\marlin\marlin\src\lcd\language;..\source\marlin\marlin\src\lcd\menu;..\source\marlin\marlin\src\lcd\menu\game;..\source\marlin\marlin\src\libs;..\source\marlin\marlin\src\module;..\source\marlin\marlin\src\module\stepper;..\source\marlin\marlin\src\module\thermistor;..\source\marlin\marlin\src\pins;..\source\marlin\marlin\src\pins\stm32f1;..\source\marlin\marlin\src\sd;..\source\marlin\marlin\src\sd\usb_flashdrive;..\source\marlin\marlin\src\sd\usb_flashdrive\lib-uhs2;..\source\marlin\marlin\src\lcd\extui;..\source\marlin\marlin\src\lcd\extui\lib\anycubic;..\source\marlin\marlin\src\lcd\extui\lib\dgus;..\source\marlin\marlin\src\lcd\extui\lib\dgus\fysetc;..\source\marlin\marlin\src\lcd\extui\lib\dgus\hiprecy;..\source\marlin\marlin\src\lcd\extui\lib\dgus\origin;..\source\marlin\marlin\src\lcd\extui\lib\ftdi_eve_touch_ui;..\source\marlin\marlin\src\lcd\extui\lib\ftdi_eve_touch_ui\archim2-flash;..\source\marlin\marlin\src\lcd\extui\lib\ftdi_eve_touch_ui\ftdi_eve_lib;..\source\marlin\marlin\src\lcd\extui\lib\ftdi_eve_touch_ui\ftdi_eve_lib\basic;..\source\marlin\marlin\src\lcd\extui\lib\ftdi_eve_touch_ui\ftdi_eve_lib\extended;..\source\marlin\marlin\src\lcd\extui\lib\ftdi_eve_touch_ui\ftdi_eve_lib\extended\unicode;..\source\marlin\marlin\src\lcd\extui\lib\ftdi_eve_touch_ui\ftdi_eve_lib\extras;..\source\marlin\marlin\src\lcd\extui\lib\ftdi_eve_touch_ui\language;..\source\marlin\marlin\src\lcd\extui\lib\ftdi_eve_touch_ui\screens;..\source\marlin\marlin\src\lcd\extui\lib\ftdi_eve_touch_ui\theme;..\source\marlin\marlin\src\lcd\extui\\lib\mks_ui;..\source\marlin\marlin\src\lcd\HD44780;..\source\marlin\marlin\src\sd\usb_flashdrive\lib-uhs3\dyn_SWI;..\source\marlin\marlin\src\sd\usb_flashdrive\lib-uhs3\UHS_host;..\source\marlin\marlin\src\sd\usb_flashdrive\lib-uhs3\UHS_host\UHS_BULK_STORAGE;..\source\marlin\marlin\src\sd\usb_flashdrive\lib-uhs3\UHS_host\USB_HOST_SHIELD;..\source\marlin\marlin\src\libs\heatshrink;..\source\marlin\marlin\src\libs\L64XX;..\source\marlin\marlin\src\lcd\dogm\status;..\source\marlin\marlin\src\lcd\dwin\e3v2;..\source\marlin\marlin\src\lcd\extui\lib\anycubic_chiron;..\source\marlin\marlin\src\lcd\extui\lib\anycubic_dgus;..\source\marlin\marlin\src\lcd\extui\lib\anycubic_i3mega;..\source\marlin\marlin\src\lcd\tft;..\source\marlin\marlin\src\lcd\tft_io;..\source\marlin\marlin\src\lcd\TFTGLCD;..\source\marlin\marlin\src\lcd\touch;..\source\marlin\marlin\src\module\stepper\source;..\source\framework\TMCStepper;..\source\framework\TMCStepper\source;..\source\arduino;..\source\board;..\source\FatFs;..\source\framework\SoftwareSerial
  library: MicroLIB
  memory RVCT4: ROM 0x8000 size 0x78000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x20010000 size 0x10000
  link misc: --keep=*Handler
  group app
    ../source/app/: main.cpp app_uart.cpp app_fatfs_test.cpp app_sserial_test.cpp
  group arduino
    ../source/arduino/: HardwareSerial.cpp Print.cpp Stream.cpp WString.cpp HardwareSerial.h Print.h Printable.h Stream.h WString.h
  group board
    ../source/board/: bsp_init.cpp bsp_init.h bsp_irq.cpp bsp_irq.h bsp_adc.cpp bsp_adc.h bsp_pwm.cpp bsp_pwm.h bsp_sdio.cpp bsp_sdio.h bsp_timer.cpp bsp_timer.h bsp_ots.cpp bsp_ots.h bsp_flash.cpp bsp_flash.h bsp_wdt.cpp bsp_wdt.h bsp_rmu.cpp
  group drivers
    ../source/drivers/library/src/: hc32f46x_adc.c hc32f46x_aes.c hc32f46x_can.c hc32f46x_clk.c hc32f46x_cmp.c hc32f46x_crc.c hc32f46x_dcu.c hc32f46x_dmac.c hc32f46x_efm.c hc32f46x_emb.c hc32f46x_event_port.c hc32f46x_exint_nmi_swi.c hc32f46x_gpio.c hc32f46x_hash.c hc32f46x_i2c.c hc32f46x_i2s.c hc32f46x_icg.c hc32f46x_interrupts.c hc32f46x_keyscan.c hc32f46x_mpu.c hc32f46x_ots.c hc32f46x_pwc.c hc32f46x_qspi.c hc32f46x_rmu.c hc32f46x_rtc.c hc32f46x_sdioc.c hc32f46x_spi.c hc32f46x_sram.c hc32f46x_swdt.c hc32f46x_timer0.c hc32f46x_timer4_cnt.c hc32f46x_timer4_emb.c hc32f46x_timer4_oco.c hc32f46x_timer4_pwm.c hc32f46x_timer4_sevt.c hc32f46x_timer6.c hc32f46x_timera.c hc32f46x_trng.c hc32f46x_usart.c hc32f46x_wdt.c hc32f46x_utility.c
  group startup
    ../source/drivers/board/: board_gpio.c board_tim0.cpp board_adc.cpp board_adc.h board_sdio.cpp board_sdio.h startup.cpp
    ../source/main/hdsc32core/: startup_hc32f46x.s system_hc32f46x.c
  group marlin
    ../source/marlin/marlin/: Configuration.h Configuration_adv.h Version.h
    ../source/marlin/marlin/src/: MarlinCore.cpp MarlinCore.h
  group src_cores
    ../source/marlin/marlin/src/core/: utility.cpp utility.h serial.cpp serial.h language.h types.h boards.h multi_language.h debug_out.h drivers.h millis_t.h debug_section.h
    ../source/framework/cores/: io.cpp flash.cpp iwdg.cpp Tone.cpp Arduino.cpp
  group src_feature
    ../source/marlin/marlin/src/feature/bedlevel/abl/: abl.cpp abl.h
    ../source/marlin/marlin/src/feature/bedlevel/: bedlevel.cpp bedlevel.h
    ../source/marlin/marlin/src/feature/: babystep.cpp babystep.h controllerfan.cpp controllerfan.h e_parser.cpp e_parser.h fwretract.cpp fwretract.h pause.cpp pause.h power_monitor.cpp power_monitor.h powerloss.cpp powerloss.h repeat.cpp repeat.h spindle_laser_types.h tmc_util.cpp tmc_util.h z_stepper_align.cpp z_stepper_align.h runout.cpp runout.h caselight.cpp caselight.h
  group src_gcode
    ../source/marlin/marlin/src/gcode/bedlevel/abl/: G29.cpp M421.cpp
    ../source/marlin/marlin/src/gcode/bedlevel/: G26.cpp G35.cpp G42.cpp M420.cpp
    ../source/marlin/marlin/src/gcode/calibrate/: G28.cpp G33.cpp G34.cpp G34_M422.cpp G76_M192_M871.cpp G425.cpp M12.cpp M48.cpp M100.cpp M425.cpp M665.cpp M666.cpp M852.cpp
    ../source/marlin/marlin/src/gcode/config/: M43.cpp M92.cpp M200-M205.cpp M217.cpp M218.cpp M220.cpp M221.cpp M281.cpp M301.cpp M302.cpp M304.cpp M305.cpp M540.cpp M575.cpp M672.cpp
    ../source/marlin/marlin/src/gcode/control/: M3-M5.cpp M7-M9.cpp M17_M18_M84.cpp M42.cpp M80_M81.cpp M85.cpp M108_M112_M410.cpp M111.cpp M120_M121.cpp M211.cpp M226.cpp M280.cpp M350_M351.cpp M380_M381.cpp M400.cpp M605.cpp M993_M994.cpp M997.cpp M999.cpp T.cpp
    ../source/marlin/marlin/src/gcode/eeprom/: M500-M504.cpp
    ../source/marlin/marlin/src/gcode/feature/digipot/: M907-M910.cpp
    ../source/marlin/marlin/src/gcode/feature/network/: M552-M554.cpp
    ../source/marlin/marlin/src/gcode/feature/pause/: G27.cpp G60.cpp G61.cpp M125.cpp M600.cpp M603.cpp M701_M702.cpp
    ../source/marlin/marlin/src/gcode/feature/power_monitor/: M430.cpp
    ../source/marlin/marlin/src/gcode/feature/powerloss/: M413.cpp M1000.cpp
    ../source/marlin/marlin/src/gcode/feature/trinamic/: M122.cpp M569.cpp M906.cpp M911-M914.cpp
    ../source/marlin/marlin/src/gcode/geometry/: G17-G19.cpp G53-G59.cpp G92.cpp M206_M428.cpp
    ../source/marlin/marlin/src/gcode/host/: M16.cpp M110.cpp M113.cpp M114.cpp M115.cpp M118.cpp M119.cpp M360.cpp M876.cpp
    ../source/marlin/marlin/src/gcode/lcd/: M0_M1.cpp M73.cpp M117.cpp M145.cpp M250.cpp M300.cpp M995.cpp
    ../source/marlin/marlin/src/gcode/motion/: G0_G1.cpp G2_G3.cpp G4.cpp G5.cpp G6.cpp G80.cpp M290.cpp
    ../source/marlin/marlin/src/gcode/probe/: G30.cpp G31_G32.cpp G38.cpp M401_M402.cpp M851.cpp M951.cpp
    ../source/marlin/marlin/src/gcode/scara/: M360-M364.cpp
    ../source/marlin/marlin/src/gcode/sd/: M20.cpp M21_M22.cpp M23.cpp M24_M25.cpp M26.cpp M27.cpp M28_M29.cpp M30.cpp M32.cpp M33.cpp M34.cpp M524.cpp M808.cpp M928.cpp M1001.cpp
    ../source/marlin/marlin/src/gcode/stats/: M31.cpp M75-M78.cpp
    ../source/marlin/marlin/src/gcode/temp/: M104_M109.cpp M105.cpp M106_M107.cpp M140_M190.cpp M141_M191.cpp M155.cpp M303.cpp
    ../source/marlin/marlin/src/gcode/units/: G20_G21.cpp M82_M83.cpp M149.cpp
    ../source/marlin/marlin/src/gcode/: gcode.cpp gcode.h gcode_d.cpp parser.cpp parser.h queue.cpp queue.h
    ../source/marlin/marlin/src/gcode/feature/controllerfan/: M710.cpp
    ../source/marlin/marlin/src/gcode/feature/runout/: M412.cpp
    ../source/marlin/marlin/src/gcode/caselight/: M355.cpp
    ../source/marlin/marlin/src/gcode/feature/advance/: M900.cpp
  group src_HAL
    ../source/marlin/marlin/src/HAL/shared/: Delay.h eeprom_api.cpp eeprom_api.h esp_wifi.cpp esp_wifi.h HAL_SPI.h HAL_spi_L6470.cpp HAL_ST7920.h Marduino.h math_32bit.h servo.cpp servo.h servo_private.h
    ../source/marlin/marlin/src/HAL/STM32/: eeprom_flash.cpp eeprom_sdcard.cpp endstop_interrupts.h fastio.h HAL.cpp HAL.h spi_pins.h timers.cpp timers.h watchdog.cpp watchdog.h sdio.cpp fastio.cpp
    ../source/marlin/marlin/src/HAL/STM32/inc/: Conditionals_adv.h Conditionals_LCD.h Conditionals_post.h SanityCheck.h
    ../source/marlin/marlin/src/HAL/: platforms.h
  group src_inc
    ../source/marlin/marlin/src/inc/: Conditionals_adv.h Conditionals_LCD.h Conditionals_post.h MarlinConfig.h MarlinConfigPre.h SanityCheck.h Version.h
  group src_lcd
    ../source/marlin/marlin/src/lcd/extui/lib/anycubic_chiron/: chiron_tft.cpp chiron_tft.h chiron_tft_defs.h FileNavigator.cpp FileNavigator.h Tunes.cpp Tunes.h
    ../source/marlin/marlin/src/lcd/extui/lib/anycubic_dgus/: dgus_FileNavigator.cpp dgus_FileNavigator.h dgus_tft.cpp dgus_tft.h dgus_tft_defs.h dgus_Tunes.cpp dgus_Tunes.h
    ../source/marlin/marlin/src/lcd/extui/: anycubic_chiron_lcd.cpp anycubic_dgus_lcd.cpp ui_api.cpp ui_api.h
    ../source/marlin/marlin/src/lcd/: buttons.h fontutils.cpp fontutils.h marlinui.cpp marlinui.h scaled_tft.h thermistornames.h
  group src_lib
    ../source/marlin/marlin/src/libs/: bresenham.h buzzer.cpp buzzer.h circularqueue.h crc16.cpp crc16.h duration_t.h hex_print.cpp hex_print.h nozzle.cpp nozzle.h numtostr.cpp numtostr.h private_spi.h softspi.h stopwatch.cpp stopwatch.h vector_3.cpp vector_3.h dtostrf.cpp dtostrf.h
  group src_module
    ../source/marlin/marlin/src/module/stepper/: indirection.cpp indirection.h trinamic.cpp trinamic.h
    ../source/marlin/marlin/src/module/: endstops.cpp endstops.h motion.cpp motion.h planner.cpp planner.h printcounter.cpp printcounter.h probe.cpp probe.h servo.cpp servo.h settings.cpp settings.h speed_lookuptable.h stepper.cpp stepper.h temperature.cpp temperature.h tool_change.cpp tool_change.h
  group src_pins
    ../source/marlin/marlin/src/pins/: pins.h sensitive_pins.h pinsDebug.h pinsDebug_list.h pins_postprocess.h
    ../source/marlin/marlin/src/pins/stm32f1/: pins_AC_TRI_F1_V1.h
  group src_sd
    ../source/marlin/marlin/src/sd/usb_flashdrive/: Sd2Card_FlashDrive.cpp Sd2Card_FlashDrive.h
    ../source/marlin/marlin/src/sd/: cardreader.cpp cardreader.h Sd2Card.cpp Sd2Card.h Sd2Card_sdio.h SdBaseFile.cpp SdBaseFile.h SdFatConfig.h SdFatStructs.h SdFatUtil.cpp SdFatUtil.h SdFile.cpp SdFile.h SdInfo.h SdVolume.cpp SdVolume.h
  group SoftwareSerial
    ../source/framework/SoftwareSerial/: SoftwareSerial.cpp SoftwareSerial.h
  group TMCStepper
    ../source/framework/TMCStepper/source/: CHOPCONF.cpp COOLCONF.cpp DRV_CONF.cpp DRV_STATUS.cpp DRVCONF.cpp DRVCTRL.cpp DRVSTATUS.cpp ENCMODE.cpp GCONF.cpp IHOLD_IRUN.cpp PWMCONF.cpp RAMP_STAT.cpp SERIAL_SWITCH.cpp SERIAL_SWITCH.h SGCSCONF.cpp SHORT_CONF.cpp SMARTEN.cpp SW_MODE.cpp SW_SPI.h TMC_MACROS.h TMC_platforms.h TMC2130_bitfields.h TMC2160_bitfields.h TMC2208_bitfields.h TMC2208Stepper.cpp TMC2209_bitfields.h TMC2209Stepper.cpp TMC2660_bitfields.h TMC5130_bitfields.h TMC5160_bitfields.h TMCStepper.cpp
  group FatFs
    ../source/FatFs/: diskio.c diskio.h ff.c ff.h ffconf.h ffsystem.c ffunicode.c
  group compent
    ../source/compoment/sdio/sd_card/src/: sd_card.c sdmmc_cmd.c
software components: CMSIS:CORE 5.4.0, CMSIS:DSP 1.8.0
